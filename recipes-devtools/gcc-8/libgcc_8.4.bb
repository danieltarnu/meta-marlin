require recipes-devtools/gcc-8/gcc-${PV}.inc
require libgcc.inc

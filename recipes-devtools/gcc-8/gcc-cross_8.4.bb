require recipes-devtools/gcc-8/gcc-${PV}.inc
require gcc-cross.inc


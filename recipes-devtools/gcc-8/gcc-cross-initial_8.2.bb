require recipes-devtools/gcc-8/gcc-cross_${PV}.bb
require gcc-cross-initial.inc

require recipes-devtools/gcc-8/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc


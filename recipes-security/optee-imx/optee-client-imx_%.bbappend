FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append = " file://0001-create-patch-for-optee-client-imx.patch \
"
